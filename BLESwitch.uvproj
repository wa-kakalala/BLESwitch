# Keil uVision project BLESwitch.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F104E Series STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: BLESwitch +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\APP;.\APP
  group BSP
    ./: STARTUP.A51
  group USER
    ./USER/: main.c
  group APP
    ./APP/: led.c uart.c steer.c ble.c
